Commit message: [master] adding box cylinder and sphere urdf

File: urdf/cylinder.urdf (robot description, URDF)
Before this commit: robot index, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.1 radius=0.05
